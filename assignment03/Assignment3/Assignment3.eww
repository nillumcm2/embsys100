<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Assignment3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\blinkdemo\Demo04_Blinking_LED_05\main.ewp</path>
    </project>
    <batchBuild />
</workspace>
